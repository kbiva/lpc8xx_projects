# Keil uVision project LPC800_mini_DS18B20.uvprojx, settings and files
target LPC800_mini_DS18B20 (6160000::V6.16::ARMCLANG)
  device: LPC810M021FN8 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IROM(0x00000000,0x1000) IRAM(0x10000000,0x0400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC800_mini_DS18B20
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;..\..\libs\lib_lpc_chip_8xx\inc;..\..\libs\lib_DS18B20\inc;..\..\libs\lib_1-Wire\inc;..\..\libs\lib_lpc800_mini_board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  group src
    ./src/: main.c nokia6100.c spi.c
  group inc
    ./inc/: font6x8.h nokia6100.h spi.h
  group libs
    ../../libs/lib_lpc_chip_8xx/Objects/: lib_lpc_chip_8xx.lib
    ../../libs/lib_1-Wire/Objects/: lib_1-Wire.lib
    ../../libs/lib_DS18B20/Objects/: lib_DS18B20.lib
    ../../libs/lib_lpc800_mini_board/Objects/: lib_lpc800_mini_board.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.0
