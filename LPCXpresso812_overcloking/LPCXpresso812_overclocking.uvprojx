# Keil uVision project LPCXpresso812_overclocking.uvprojx, settings and files
target LPCXpresso812_overclocking (6160000::V6.16::ARMCLANG)
  device: LPC812M101JDH20 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPCXpresso812_overclocking
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=1
  c define: CORE_M0PLUS
  c include: .\inc;..\..\libs\lib_lpc_chip_8xx\inc;..\..\libs\lib_xprintf\inc;..\..\libs\lib_nxp_lpcxpresso_812_board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group src
    ./src/: main.c nokia6100.c spi.c delay.c
  group inc
    ./inc/: font6x8.h nokia6100.h spi.h delay.h
  group libs
    ../../libs/lib_lpc_chip_8xx/Objects/: lib_lpc_chip_8xx.lib
    ../../libs/lib_xprintf/Objects/: lib_xprintf.lib
    ../../libs/lib_nxp_lpcxpresso_812_board/Objects/: lib_nxp_lpcxpresso_812_board.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
