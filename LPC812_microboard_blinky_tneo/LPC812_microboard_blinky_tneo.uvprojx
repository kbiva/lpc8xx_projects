# Keil uVision project LPC812_microboard_blinky_tneo.uvprojx, settings and files
target LPC812_microboard_blinky_tneo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC812_microboard_blinky_tneo +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\libs\lib_lpc_chip_8xx\inc;..\..\libs\lib_TNeo\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group startup
    ./startup/: system_LPC8xx.c startup_LPC8xx.s
  group src
    ./src/: main.c tn_app_check.c
  group libs
    ../../libs/lib_lpc_chip_8xx/obj/: lib_lpc_chip_8xx.lib
    ../../libs/lib_TNeo/Objects/: lib_TNeo.lib
