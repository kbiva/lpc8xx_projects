# Keil uVision project LPC812_clock.uvprojx, settings and files
target LPC812_clock (ARM-ADS)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC812_clock
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: CORE_M0PLUS
  c include: .\inc;..\lib_lpc_chip_8xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group startup
    ./startup/: system_LPC8xx.c startup_LPC8xx.s
  group inc
    ./inc/: PCA2129T.h PCF2103.h i2c.h 24C32WI.h pins.h
  group src
    ./src/: main.c i2c.c pins.c
  group libs
    ../lib_lpc_chip_8xx/obj/: lib_lpc_chip_8xx.lib
