# Keil uVision project LPCXpresso812_RC5_7segment.uvprojx, settings and files
target LPCXpresso812_RC5_7segment (6160000::V6.16::ARMCLANG)
  device: LPC812M101JDH20 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPCXpresso812_RC5_7segment
  c flags: Optim=5 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;..\..\libs\lib_lpc_chip_8xx\inc;..\..\libs\lib_2_5_digits_indicator\inc;..\..\libs\lib_nxp_lpcxpresso_812_board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group src
    ./src/: main.c sct_fsm.c rc5.c
  group inc
    ./inc/: sct_fsm.h sct_user.h rc5.h
  group libs
    ../../libs/lib_lpc_chip_8xx/Objects/: lib_lpc_chip_8xx.lib
    ../../libs/lib_2_5_digits_indicator/Objects/: lib_2_5_digits_indicator.lib
    ../../libs/lib_nxp_lpcxpresso_812_board/Objects/: lib_nxp_lpcxpresso_812_board.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
