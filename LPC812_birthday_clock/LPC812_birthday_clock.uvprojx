# Keil uVision project LPC812_birthday_clock.uvprojx, settings and files
target LPC812_birthday_clock (6190000::V6.19::ARMCLANG)
  device: LPC812M101JD20 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC812_birthday_clock
  c flags: Optim=6 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CORE_M0PLUS
  c include: .\inc;..\..\libs\lib_lpc_chip_8xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group inc
    ./inc/: PCA2129T.h PCF2103.h i2c.h 24C32WI.h pins.h clock.h
  group src
    ./src/: i2c.c pins.c clock.c display_clock.c
  group libs
    ../../libs/lib_lpc_chip_8xx/Objects/: lib_lpc_chip_8xx.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
