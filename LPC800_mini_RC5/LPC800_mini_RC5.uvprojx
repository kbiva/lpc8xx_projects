# Keil uVision project LPC800_mini_RC5.uvprojx, settings and files
target LPC800_mini_RC5 (ARM-ADS)
  device: LPC810M021FN8 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x1000) IRAM(0x10000000,0x0400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC800_mini_RC5
  c flags: Optim=4 OneElfS=1
  c define: CORE_M0PLUS
  c include: .\inc;..\..\libs\lib_lpc_chip_8xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  group startup
    ./startup/: system_LPC8xx.c startup_LPC8xx.s
  group src
    ./src/: main.c nokia6100.c spi.c sct_fsm.c rc5.c
  group inc
    ./inc/: font6x8.h nokia6100.h spi.h sct_fsm.h sct_user.h rc5.h
  group libs
    ../../libs/lib_lpc_chip_8xx/obj/: lib_lpc_chip_8xx.lib
